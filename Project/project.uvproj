# Keil uVision project project.uvproj, settings and files
target meter (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: project +hex
  c flags: Optimize=8
  c define: FOSC_160000
  c include: ..\Common\inc;..\App\inc;..\Bsp\inc;..\Startup;..\Bsp
  asm include: ..\Common\inc
  group App
    ../App/src/: main.c app_work.c app_repeat_exe.c app_2d4.c app_uart.c app_crc.c app_dome.c app_eeprom.c
    ../App/inc/: app.h
  group Bsp
    ../Bsp/: bsp.c
    ../Bsp/src/: bsp_uart.c bsp_timer0.c bsp_2d4.c bsp_light.c bsp_relay.c bsp_eeprom.c bsp_key.c
  group Common
    ../Common/src/: Common.c Delay.c Version.c
  group Startup
    ../Startup/: STARTUP.A51
  group Doc
    ../Doc/: readme.txt
